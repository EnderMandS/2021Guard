# Keil uVision project CboardGuard.uvprojx, settings and files
target CboardGuard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: CboardGuard +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\UserCode\Bsp\bsp_can; ..\UserCode\APP\CanInfo; ..\UserCode\Bsp\Bsp_usart; ..\UserCode\APP\remote control; ..\UserCode\APP\UsartInfo; ..\UserCode\Judge; ..\UserCode\APP\pid; ..\UserCode\Gimbal; ..\UserCode\APP\Filter; ..\UserCode\Shoot; ..\UserCode\Chassic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Bsp/Applicatiion
    ../UserCode/Bsp/bsp_can/: bsp_can.c
    ../UserCode/Bsp/Bsp_usart/: bsp_usart.c
  group APP
    ../UserCode/APP/CanInfo/: caninfo.c
    ../UserCode/APP/remote control/: Remote_Control.c
    ../UserCode/APP/UsartInfo/: usartinfo.c
    ../UserCode/APP/pid/: pid.c
    ../UserCode/APP/Filter/: Filter.c
  group Gimbal
    ../UserCode/Gimbal/: Gimbal.c
  group Chassic
    ../UserCode/Chassic/: classic.c
  group Judge
    ../UserCode/Judge/: crc.c judge.c guard_judge.c
  group Shoot
    ../UserCode/Shoot/: shoot.c
software components: CMSIS:CORE 4.3.0
